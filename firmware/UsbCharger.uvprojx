# Keil uVision project UsbCharger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32660 Maxim
  pack: Maxim.MAX32660.1.1.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UsbCharger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./Source/: main.c max1726x.c my_board.c max14748.c max14746.c protocol.c
software components: CMSIS:CORE 5.1.2, BSP:Board Support 1.1.2, Communications:I2C 1.1.2, Communications:UART 1.1.2, Device:Startup 1.1.2, Peripherals:GPIO 1.1.2, Peripherals:RTC 1.1.2, Peripherals:Timers 1.1.2
